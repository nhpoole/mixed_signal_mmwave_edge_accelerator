$ Spice netlist generated by v2lvs
$ v2019.1_18.11    Thu Jan 10 13:52:35 PST 2019
.INCLUDE "inputs/design_extracted.spice"
.INCLUDE "source.added"
*.BUSDELIMITER [
