v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 170 -220 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 170 -200 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 170 -180 0 0 {name=p3 lab=clk}
C {devices/ipin.sym} 170 -160 0 0 {name=p4 lab=rst_n}
C {devices/ipin.sym} 170 -140 0 0 {name=p5 lab=adc_start}
C {devices/ipin.sym} 170 -120 0 0 {name=p6 lab=comparator_val}
C {devices/opin.sym} 220 -220 0 0 {name=p7 lab=run_adc_n}
C {devices/opin.sym} 220 -200 0 0 {name=p8 lab=adc_val[0]}
C {devices/opin.sym} 220 -40 0 0 {name=p9 lab=out_valid}
C {devices/opin.sym} 220 -180 0 0 {name=p10 lab=adc_val[1]}
C {devices/opin.sym} 220 -160 0 0 {name=p11 lab=adc_val[2]}
C {devices/opin.sym} 220 -140 0 0 {name=p12 lab=adc_val[3]}
C {devices/opin.sym} 220 -120 0 0 {name=p13 lab=adc_val[4]}
C {devices/opin.sym} 220 -100 0 0 {name=p14 lab=adc_val[5]}
C {devices/opin.sym} 220 -80 0 0 {name=p15 lab=adc_val[6]}
C {devices/opin.sym} 220 -60 0 0 {name=p16 lab=adc_val[7]}
