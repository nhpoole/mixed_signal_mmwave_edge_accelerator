v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 180 -560 0 0 {name=p1 lab=VDD}
C {devices/ipin.sym} 180 -540 0 0 {name=p2 lab=VSS}
C {devices/ipin.sym} 180 -520 0 0 {name=p3 lab=clk}
C {devices/ipin.sym} 180 -500 0 0 {name=p4 lab=rst_n}
C {devices/ipin.sym} 180 -480 0 0 {name=p5 lab=load_en}
C {devices/ipin.sym} 180 -460 0 0 {name=p6 lab=debug_en}
C {devices/opin.sym} 230 -560 0 0 {name=p7 lab=serial_out}
C {devices/opin.sym} 230 -540 0 0 {name=p8 lab=serial_out_valid}
C {devices/opin.sym} 230 -520 0 0 {name=p9 lab=freq_eval_done}
C {devices/ipin.sym} 180 -440 0 0 {name=p10 lab=serial_in}
C {devices/ipin.sym} 180 -420 0 0 {name=p11 lab=sram_select[0]}
C {devices/ipin.sym} 180 -400 0 0 {name=p12 lab=sram_select[1]}
C {devices/ipin.sym} 180 -380 0 0 {name=p13 lab=frequency_adc_done}
C {devices/ipin.sym} 180 -360 0 0 {name=p14 lab=amplitude_adc_done}
C {devices/ipin.sym} 180 -340 0 0 {name=p15 lab=sig_frequency[0]}
C {devices/ipin.sym} 180 -320 0 0 {name=p16 lab=sig_frequency[1]}
C {devices/ipin.sym} 180 -300 0 0 {name=p17 lab=sig_frequency[2]}
C {devices/ipin.sym} 180 -280 0 0 {name=p18 lab=sig_frequency[3]}
C {devices/ipin.sym} 180 -260 0 0 {name=p19 lab=sig_frequency[4]}
C {devices/ipin.sym} 180 -240 0 0 {name=p20 lab=sig_frequency[5]}
C {devices/ipin.sym} 180 -220 0 0 {name=p21 lab=sig_frequency[6]}
C {devices/ipin.sym} 180 -200 0 0 {name=p22 lab=sig_frequency[7]}
C {devices/ipin.sym} 180 -180 0 0 {name=p23 lab=sig_amplitude[0]}
C {devices/ipin.sym} 180 -160 0 0 {name=p24 lab=sig_amplitude[1]}
C {devices/ipin.sym} 180 -140 0 0 {name=p25 lab=sig_amplitude[2]}
C {devices/ipin.sym} 180 -120 0 0 {name=p26 lab=sig_amplitude[3]}
C {devices/ipin.sym} 180 -100 0 0 {name=p27 lab=sig_amplitude[4]}
C {devices/ipin.sym} 180 -80 0 0 {name=p28 lab=sig_amplitude[5]}
C {devices/ipin.sym} 180 -60 0 0 {name=p29 lab=sig_amplitude[6]}
C {devices/ipin.sym} 180 -40 0 0 {name=p30 lab=sig_amplitude[7]}
C {devices/ipin.sym} 180 -20 0 0 {name=p31 lab=adc_bypass_en}
