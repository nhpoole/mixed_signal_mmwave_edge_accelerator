** sch_path: designs/and3.sch
**.subckt and3 A B Y C
*.ipin A
*.ipin B
*.opin Y
*.ipin C
x2 net1 Y net2 net3 inv M=M
x1 A B C net1 net4 net5 nand3 M=M
**.ends
.end
